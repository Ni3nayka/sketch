char morse_code(int (F)[]) { // char b = morse_code(mas); // mas[n>10] for 0.;1-;2 over
  char f = 0;
  if      ((F[0] == 0) && (F[1] == 1) && (F[2] == 2))                                f = 'a';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 0) && (F[3] == 0) && (F[4] == 2))  f = 'b';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 1) && (F[3] == 0) && (F[4] == 2))  f = 'c';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 0) && (F[3] == 2))                 f = 'd';
  else if ((F[0] == 0) && (F[1] == 2))                                               f = 'e';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 1) && (F[3] == 0) && (F[4] == 2))  f = 'f';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 0) && (F[3] == 2))                 f = 'g';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 0) && (F[4] == 2))  f = 'h';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 2))                                f = 'i';
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 1) && (F[3] == 1) && (F[4] == 2))  f = 'j';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 1) && (F[3] == 2))                 f = 'k';
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 0) && (F[3] == 0) && (F[4] == 2))  f = 'l';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 2))                                f = 'm';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 2))                                f = 'n';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 1) && (F[3] == 2))                 f = 'o';
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 1) && (F[3] == 0) && (F[4] == 2))  f = 'p';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 0) && (F[3] == 1) && (F[4] == 2))  f = 'q';
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 0) && (F[3] == 2))                 f = 'r';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 2))                 f = 's';
  else if ((F[0] == 1) && (F[1] == 2))                                               f = 't';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 1) && (F[3] == 2))                 f = 'u';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 1) && (F[4] == 2))  f = 'v';
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 1) && (F[3] == 2))                 f = 'w';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 0) && (F[3] == 1) && (F[4] == 2))  f = 'x';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 1) && (F[3] == 1) && (F[4] == 2))  f = 'y';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 0) && (F[3] == 0) && (F[4] == 2))  f = 'z';
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 1) && (F[3] == 1) && (F[4] == 1) && (F[5] == 2))  f = '1';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 1) && (F[3] == 1) && (F[4] == 1) && (F[5] == 2))  f = '2';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 1) && (F[4] == 1) && (F[5] == 2))  f = '3';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 0) && (F[4] == 1) && (F[5] == 2))  f = '4';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 0) && (F[4] == 0) && (F[5] == 2))  f = '5';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 0) && (F[3] == 0) && (F[4] == 0) && (F[5] == 2))  f = '6';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 0) && (F[3] == 0) && (F[4] == 0) && (F[5] == 2))  f = '7';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 1) && (F[3] == 0) && (F[4] == 0) && (F[5] == 2))  f = '8';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 1) && (F[3] == 1) && (F[4] == 0) && (F[5] == 2))  f = '9';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 1) && (F[3] == 1) && (F[4] == 1) && (F[5] == 2))  f = '0';
  
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 0) && (F[4] == 0) && (F[5] == 0) && (F[6] == 2))  f = '/';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 1) && (F[3] == 0) && (F[4] == 1) && (F[5] == 0) && (F[6] == 2))  f = ';';
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 0) && (F[3] == 1) && (F[4] == 0) && (F[5] == 1) && (F[6] == 2))  f = ',';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 1) && (F[3] == 0) && (F[4] == 0) && (F[5] == 0) && (F[6] == 2))  f = ':';
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 1) && (F[3] == 1) && (F[4] == 0) && (F[5] == 0) && (F[6] == 2))  f = '?';
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 0) && (F[3] == 0) && (F[4] == 1) && (F[5] == 1) && (F[6] == 2))  f = '!';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 0) && (F[3] == 0) && (F[4] == 0) && (F[5] == 1) && (F[6] == 2))  f = '-';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 1) && (F[3] == 1) && (F[4] == 0) && (F[5] == 1) && (F[6] == 2))  f = '|'; // ()
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 0) && (F[3] == 0) && (F[4] == 1) && (F[5] == 0) && (F[6] == 2))  f = '"';
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 0) && (F[3] == 0) && (F[4] == 1) && (F[5] == 2))  f = ' '; // разделяющий знак
  else if ((F[0] == 1) && (F[1] == 0) && (F[2] == 1) && (F[3] == 0) && (F[4] == 1) && (F[5] == 2))  f = 'S'; // начало передачи (start)
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 0) && (F[3] == 1) && (F[4] == 0) && (F[5] == 2))  f = 'O'; // конец передачи (over) или +
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 0) && (F[3] == 0) && (F[4] == 0) && (F[5] == 2))  f = 'W'; // ждать (wait)
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 1) && (F[4] == 0) && (F[5] == 1) && (F[6] == 2))  f = 'G'; // полный конец работы (global over)
  
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 0) && (F[4] == 0) && (F[5] == 0) && (F[6] == 0) && (F[7] == 0) && (F[8] == 2))                f = 'E'; // ошибка (error)
  else if ((F[0] == 0) && (F[1] == 0) && (F[2] == 0) && (F[3] == 1) && (F[4] == 1) && (F[5] == 1) && (F[6] == 0) && (F[7] == 0) && (F[8] == 0) && (F[9] == 2)) f = 'H'; // SOS
  
  else if ((F[0] == 1) && (F[1] == 1) && (F[2] == 1) && (F[3] == 1) && (F[4] == 2))  f = ' ';
  else if ((F[0] == 0) && (F[1] == 1) && (F[2] == 0) && (F[3] == 1) && (F[4] == 2))  f = 'X'; // delete last symbol
  else f = 'E';
  return f;    
}

void abc_code(char f, int (&F)[10]) {
  if      (f == 'a') { F[0] = 0; F[1] = 1; F[2] = 2;  }                               
  else if (f == 'b') { F[0] = 1; F[1] = 0; F[2] = 0; F[3] = 0; F[4] = 2;  }
  else if (f == 'c') { F[0] = 1; F[1] = 0; F[2] = 1; F[3] = 0; F[4] = 2;  } 
  else if (f == 'd') { F[0] = 1; F[1] = 0; F[2] = 0; F[3] = 2;  }             
  else if (f == 'e') { F[0] = 0; F[1] = 2;  }                                         
  else if (f == 'f') { F[0] = 0; F[1] = 0; F[2] = 1; F[3] = 0; F[4] = 2;  } 
  else if (f == 'g') { F[0] = 1; F[1] = 1; F[2] = 0; F[3] = 2;  }               
  else if (f == 'h') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 0; F[4] = 2;  }
  else if (f == 'i') { F[0] = 0; F[1] = 0; F[2] = 2;  }                         
  else if (f == 'j') { F[0] = 0; F[1] = 1; F[2] = 1; F[3] = 1; F[4] = 2;  } 
  else if (f == 'k') { F[0] = 1; F[1] = 0; F[2] = 1; F[3] = 2;  }            
  else if (f == 'l') { F[0] = 0; F[1] = 1; F[2] = 0; F[3] = 0; F[4] = 2;  } 
  else if (f == 'm') { F[0] = 1; F[1] = 1; F[2] = 2;  }                             
  else if (f == 'n') { F[0] = 1; F[1] = 0; F[2] = 2;  }                             
  else if (f == 'o') { F[0] = 1; F[1] = 1; F[2] = 1; F[3] = 2;  }            
  else if (f == 'p') { F[0] = 0; F[1] = 1; F[2] = 1; F[3] = 0; F[4] = 2;  } 
  else if (f == 'q') { F[0] = 1; F[1] = 1; F[2] = 0; F[3] = 1; F[4] = 2;  }  
  else if (f == 'r') { F[0] = 0; F[1] = 1; F[2] = 0; F[3] = 2;  }             
  else if (f == 's') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 2;  }            
  else if (f == 't') { F[0] = 1; F[1] = 2;  }                                             
  else if (f == 'u') { F[0] = 0; F[1] = 0; F[2] = 1; F[3] = 2;  }           
  else if (f == 'v') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 1; F[4] = 2;  } 
  else if (f == 'w') { F[0] = 0; F[1] = 1; F[2] = 1; F[3] = 2;  }               
  else if (f == 'x') { F[0] = 1; F[1] = 0; F[2] = 0; F[3] = 1; F[4] = 2;  } 
  else if (f == 'y') { F[0] = 1; F[1] = 0; F[2] = 1; F[3] = 1; F[4] = 2;  } 
  else if (f == 'z') { F[0] = 1; F[1] = 1; F[2] = 0; F[3] = 0; F[4] = 2;  } 
  else if (f == '1') { F[0] = 0; F[1] = 1; F[2] = 1; F[3] = 1; F[4] = 1; F[5] = 2;  }
  else if (f == '2') { F[0] = 0; F[1] = 0; F[2] = 1; F[3] = 1; F[4] = 1; F[5] = 2;  }
  else if (f == '3') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 1; F[4] = 1; F[5] = 2;  }
  else if (f == '4') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 0; F[4] = 1; F[5] = 2;  }
  else if (f == '5') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 0; F[4] = 0; F[5] = 2;  }
  else if (f == '6') { F[0] = 1; F[1] = 0; F[2] = 0; F[3] = 0; F[4] = 0; F[5] = 2;  }
  else if (f == '7') { F[0] = 1; F[1] = 1; F[2] = 0; F[3] = 0; F[4] = 0; F[5] = 2;  }
  else if (f == '8') { F[0] = 1; F[1] = 1; F[2] = 1; F[3] = 0; F[4] = 0; F[5] = 2;  }
  else if (f == '9') { F[0] = 1; F[1] = 1; F[2] = 1; F[3] = 1; F[4] = 0; F[5] = 2;  } 
  else if (f == '0') { F[0] = 1; F[1] = 1; F[2] = 1; F[3] = 1; F[4] = 1; F[5] = 2;  }
  
  else if (f == '/') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 0; F[4] = 0; F[5] = 0; F[6] = 2;  }
  else if (f == ';') { F[0] = 1; F[1] = 0; F[2] = 1; F[3] = 0; F[4] = 1; F[5] = 0; F[6] = 2;  }
  else if (f == ',') { F[0] = 0; F[1] = 1; F[2] = 0; F[3] = 1; F[4] = 0; F[5] = 1; F[6] = 2;  }
  else if (f == ':') { F[0] = 1; F[1] = 1; F[2] = 1; F[3] = 0; F[4] = 0; F[5] = 0; F[6] = 2;  }
  else if (f == '?') { F[0] = 0; F[1] = 0; F[2] = 1; F[3] = 1; F[4] = 0; F[5] = 0; F[6] = 2;  }
  else if (f == '!') { F[0] = 1; F[1] = 1; F[2] = 0; F[3] = 0; F[4] = 1; F[5] = 1; F[6] = 2;  }
  else if (f == '-') { F[0] = 1; F[1] = 0; F[2] = 0; F[3] = 0; F[4] = 0; F[5] = 1; F[6] = 2;  }
  else if (f == '|') { F[0] = 1; F[1] = 0; F[2] = 1; F[3] = 1; F[4] = 0; F[5] = 1; F[6] = 2;  } // ()
  else if (f == '"') { F[0] = 0; F[1] = 1; F[2] = 0; F[3] = 0; F[4] = 1; F[5] = 0; F[6] = 2;  }
  //else if (f == ' ') { F[0] = 1; F[1] = 0; F[2] = 0; F[3] = 0; F[4] = 1; F[5] = 2;  } // разделяющий знак
  else if (f == 'S') { F[0] = 1; F[1] = 0; F[2] = 1; F[3] = 0; F[4] = 1; F[5] = 2;  } // начало передачи (start)
  else if (f == 'O') { F[0] = 0; F[1] = 1; F[2] = 0; F[3] = 1; F[4] = 0; F[5] = 2;  } // конец передачи (over) или +
  else if (f == 'W') { F[0] = 0; F[1] = 1; F[2] = 0; F[3] = 0; F[4] = 0; F[5] = 2;  } // ждать (wait)
  else if (f == 'G') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 1; F[4] = 0; F[5] = 1; F[6] = 2;  } // полный конец работы (global over)
  
  else if (f == 'E') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 0; F[4] = 0; F[5] = 0; F[6] = 0; F[7] = 0; F[8] = 2;  } // ошибка (error)
  else if (f == 'H') { F[0] = 0; F[1] = 0; F[2] = 0; F[3] = 1; F[4] = 1; F[5] = 1; F[6] = 0; F[7] = 0; F[8] = 0; F[9] = 2;  } // SOS
  
  else if (f == ' ') { F[0] = 1; F[1] = 1; F[2] = 1; F[3] = 1; F[4] = 2;  }
  else if (f == 'X') { F[0] = 0; F[1] = 1; F[2] = 0; F[3] = 1; F[4] = 2;  } // delete last symbol
  else f = 'E';
  return f;    
}

boolean abc_test(char f) {
  boolean a = 0;
  if ((f == 'a') || (f == 'b') || (f == 'c') || (f == 'd') || (f == 'e') || (f == 'f') || (f == 'g') || (f == 'h') || (f == 'i') || (f == 'j') || (f == 'k') || (f == 'l') || (f == 'm') || (f == 'n') || (f == 'o') || (f == 'p') || (f == 'q') || (f == 'r') || (f == 's') || (f == 't') || (f == 'u') || (f == 'v') || (f == 'w') || (f == 'x') || (f == 'y') || (f == 'z') || (f == '1') || (f == '2') || (f == '3') || (f == '4') || (f == '5') || (f == '6') || (f == '7') || (f == '8') || (f == '9') || (f == '0') || (f == '/') || (f == ';') || (f == ',') || (f == ':') || (f == '?') || (f == '!') || (f == '-') || (f == '|') || (f == '"') || (f == ' ') || (f == 'S') || (f == 'O') || (f == 'W') || (f == 'G') || (f == 'E') || (f == 'H') || (f == ' ') || (f == 'X')) a = 1;        
  return a;
}
